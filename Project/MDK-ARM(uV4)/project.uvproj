# Keil uVision project project.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\rtthread-nano\rt-thread\include;..\..\User\SEGGER_RTT\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../../User/app/src/: startup.c application.c
  group ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group Bsp
    ../../User/bsp/: board.c bsp_led.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SEGGER_RTT
    ../../User/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group rtthread-nano
    ../../User/rtthread-nano/rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ../../User/rtthread-nano/rt-thread/include/: rtconfig.h
  group CROTEX-M3
    ../../User/rtthread-nano/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../User/rtthread-nano/rt-thread/libcpu/arm/common/: backtrace.c div0.c
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\fonts;..\..\User\images;..\..\User\uIP\uip;..\..\User\uIP\http;..\..\User\uIP\dm9000;..\..\User\FatFS\src;..\..\User\usb_mass;..\..\User\CH376\inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
